## application/boards/ek_ra8d1.conf
```kconfig
CONFIG_LV_Z_MEM_POOL_SIZE=245760
CONFIG_LV_DRAW_LAYER_SIMPLE_BUF_SIZE=49152
CONFIG_LV_ATTRIBUTE_MEM_ALIGN_SIZE=64
```
